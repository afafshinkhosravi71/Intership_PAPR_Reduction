<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dvbs_tx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1280e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate * 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>8000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>89</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vga1_gain</value></param>
<param><key>value</key><value>-8</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-35</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-4</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vga2_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>adv.cfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/herve/Documents/Script_GNURadio/vv017-paprtr.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbs2_modulator_bc</key>
<param><key>id</key><value>dtv_dvbs2_modulator_bc_0</value></param>
<param><key>interpolation</key><value>INTERPOLATION_ON</value></param>
<param><key>rate1</key><value>C1_4</value></param>
<param><key>constellation</key><value>MOD_QPSK</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt_convolutional_interleaver</key>
<param><key>id</key><value>dtv_dvbt_convolutional_interleaver_0</value></param>
<param><key>blocks</key><value>136</value></param>
<param><key>M</key><value>17</value></param>
<param><key>I</key><value>12</value></param>
</block>
<block>
<key>dtv_dvbt_energy_dispersal</key>
<param><key>id</key><value>dtv_dvbt_energy_dispersal_0</value></param>
<param><key>nsize</key><value>1</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0</value></param>
<param><key>code_rate</key><value>C7_8</value></param>
<param><key>constellation</key><value>qpsk</value></param>
<param><key>hierarchy</key><value>nh</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0</value></param>
<param><key>blocks</key><value>8</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, 0.35, rrc_taps)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>vga1_gain</value></param>
<param><key>bw0</key><value>10000000</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>vga2_gain</value></param>
<param><key>args</key><value>bladerf=0,buffers=128,buflen=32768</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, ((symbol_rate * 1.35) / 2 ) + 1e5)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"send_frame_size=65536,num_send_frames=256,master_clock_rate=" + str(samp_rate*2)</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dtv_dvbt_energy_dispersal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>dtv_dvbs2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbs2_modulator_bc_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_convolutional_interleaver_0</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_energy_dispersal_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0</source_block_id><sink_block_id>dtv_dvbt_convolutional_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
